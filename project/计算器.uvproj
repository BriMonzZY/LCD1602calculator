# Keil uVision project 计算器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 计算器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group sorucefile
    ../source_files/: main.c lcd1602.c app.c key.c postfix_expression.c
  group includefile
    ../source_files/: main.h config.h lcd1602.h app.h key.h postfix_expression.h
